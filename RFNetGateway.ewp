# IAR project RFNetGateway.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K4 STM8S105K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 1650
  General.GenHeapSize: 350
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; Drivers\inc; Protocol
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: RFNetGateway.srec
  ILINK.IlinkOutputFile: RFNetGateway.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: enc28j60.c enc28j60.h lcd_digtron.c main.c main.h misc.c stm8s_it.c
    Protocol/: includes.h
  group drivers
    Drivers/src/: stm8s_adc1.c stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_can.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_tim5.c stm8s_tim6.c stm8s_uart1.c stm8s_uart2.c stm8s_uart3.c stm8s_wwdg.c
  group protocol
    Protocol/: arp.c ethernet.c http.c icmp.c ip.c tcp.c udp.c
